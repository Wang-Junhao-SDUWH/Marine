# Keil uVision project 三五计划.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 三五计划 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 dataPro.c DS18B20.c Lcd1602.c main.c DS18B20.h lcd.h TDScollection.c PCF8591.c I2C.c I2C.h PCF8591.h Include.h
